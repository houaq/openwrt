## target/linux/imx6ul/image/Config.in
```kconfig
config IMX6UL_SD_BOOT_PARTSIZE
	int "Boot (SD Card) filesystem partition size (in MB)"
	depends on TARGET_imx6ul
	default 20
```
